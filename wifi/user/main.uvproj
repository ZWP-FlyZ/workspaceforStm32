# Keil uVision project main.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\system\delay;..\system\sys;..\system\usart;..\hardware\led;..\hardware\USART2;..\wifi;..\hardware\Init;..\Command
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./: startup_stm32f10x_hd.s main.c
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group hardware
    ../hardware/led/: LED.c
    ../hardware/USART2/: usart2.c
  group wifi
    ../wifi/: common.c wifista.c
  group init
    ../hardware/Init/: init.c
  group command
    ../Command/: command.c task.c
